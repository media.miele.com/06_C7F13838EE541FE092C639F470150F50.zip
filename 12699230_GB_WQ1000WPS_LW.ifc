Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 18ca6026-c5d5-4690-9eab-e8379fe48835, NumberOfSaves: 1]
File name: 0001
Time: 2025-06-12T10:44:09+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12699230_GB_WQ1000WPS_LW:11Q10002_GB_12699230_WQ1000WPS_LW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Water_IN, z_Miele_Connection_AW, z_Miele_Connection_Condensate, z_Miele_Connection_Connection_Modul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 620 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 11Q10002_GB_12699230_WQ1000WPS_LW; sets with these values: 2
